# IAR project SPIRIT1-WMBUS_Example.ewp, settings and files
configuration wmbus_vcom-concentrator-868 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xC ST STM32L152xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; STM32L1XX_MD; IAR_ARM_CM3; USE_FULL_ASSERT; SPIRIT_USE_VCOM_ASSERT; USE_SYSTICK_DELAY; DEVICE_TYPE=OTHER; DEVICE_BAND=868; DEVICE_METER_TYPE=0x31; AES_CBC_ENABLEx
  ICCARM.CCIncludePath2: ..\..\STM32L1xx_StdPeriph_Lib\Source\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc; ..\..\STM32_USB-FS-Device_Lib\Source\inc; ..\..\SDK_Virtual_Com\Source\inc; ..\..\..\SPIRIT1_Library_Project\SPIRIT1_Library\Source\inc; ..\..\SDK_Eval_STM32L\Source\inc; ..\..\..\SPIRIT1_Library_Project\SDK_Eval_Util\Source\inc; ..\..\WMBUS_Libraries_STM32L\link\inc; ..\..\WMBUS_Libraries_STM32L\phy\inc; ..\..\WMBUS_Libraries_STM32L\appli\inc; ..\Sample_Application\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPIRIT1-wmbus_vcom-concentrator-868.hex
  ILINK.IlinkOutputFile: SPIRIT1-wmbus_vcom-concentrator-868.out
  ILINK.IlinkIcfFile: stm32l1xx_flash_offset.icf
  ILINK.IlinkAdditionalLibs: ..\..\WMBUS_Libraries_STM32L\Library\SPIRIT_WMBUS_STM32L_Library.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration wmbus_vcom-concentrator-169 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; STM32L1XX_MD; IAR_ARM_CM3; USE_FULL_ASSERT; SPIRIT_USE_VCOM_ASSERT; USE_SYSTICK_DELAY; DEVICE_TYPE=OTHER; DEVICE_BAND=169; DEVICE_METER_TYPE=0x31
  OBJCOPY.OOCOutputFile: SPIRIT1-wmbus_vcom-concentrator-169.hex
  ILINK.IlinkOutputFile: SPIRIT1-wmbus_vcom-concentrator-169.out
configuration wmbus_vcom-meter-868 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; STM32L1XX_MD; IAR_ARM_CM3; USE_FULL_ASSERT; SPIRIT_USE_VCOM_ASSERT; USE_SYSTICK_DELAY; DEVICE_TYPE=METER; DEVICE_BAND=868; DEVICE_METER_TYPE=0x02; AES_CBC_ENABLEx
  OBJCOPY.OOCOutputFile: SPIRIT1-wmbus_vcom-meter-868.hex
  ILINK.IlinkOutputFile: SPIRIT1-wmbus_vcom-meter-868.out
configuration wmbus_vcom-meter-169 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; STM32L1XX_MD; IAR_ARM_CM3; USE_FULL_ASSERT; SPIRIT_USE_VCOM_ASSERT; USE_SYSTICK_DELAY; DEVICE_TYPE=METER; DEVICE_BAND=169; DEVICE_METER_TYPE=0x02
  OBJCOPY.OOCOutputFile: SPIRIT1-wmbus_vcom-meter-169.hex
  ILINK.IlinkOutputFile: SPIRIT1-wmbus_vcom-meter-169.out
  group Runtime
    ../../STM32L1xx_StdPeriph_Lib/Source/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
    ../../STM32L1xx_StdPeriph_Lib/Source/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/: system_stm32l1xx.c
  group SPIRIT1_Libraries
    ../../../SPIRIT1_Library_Project/SPIRIT1_Library/Source/src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group STM32_USB-FS-Device_Driver
    ../../STM32_USB-FS-Device_Lib/Source/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32L1xx_StdPeriph_Lib
    ../../STM32L1xx_StdPeriph_Lib/Source/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group WMBUS_Application/Sample_Application/inc
    ../Sample_Application/inc/: main.h stm32l1xx_conf.h stm32l1xx_it.h
    ../../../SPIRIT1_Library_Project/SDK_Eval_Util/Source/inc/: SPIRIT_SDK_Util.h
  group WMBUS_Application/Sample_Application/src
    ../Sample_Application/src/: main_vcom.c stm32l1xx_it.c
    ../../../SPIRIT1_Library_Project/SDK_Eval_Util/Source/src/: SPIRIT_SDK_Util.c
  group WMBUS_Application/SDK_Eval
    ../../SDK_Eval_STM32L/Source/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_EEPROM.c SDK_EVAL_Gpio.c SDK_EVAL_Led.c SDK_EVAL_PM.c SDK_EVAL_Spi_Driver.c SDK_EVAL_Timers.c
  group WMBUS_Application/SDK_Virtual_Com
    ../../SDK_Virtual_Com/Source/src/: SDK_EVAL_VC_Desc.c SDK_EVAL_VC_Endp.c SDK_EVAL_VC_General.c SDK_EVAL_VC_Istr.c SDK_EVAL_VC_Prop.c SDK_EVAL_VC_Pwr.c
  group WMBUS_Application/WMBus_appli/inc
    ../../WMBUS_Libraries_STM32L/appli/inc/: aes128.h Serial.h wmbus_appli.h wmbus_phydatamem.h wmbus_userInterface.h
  group WMBUS_Application/WMBus_appli/src
    ../../WMBUS_Libraries_STM32L/appli/src/: aes128.c aes128_ctr.c Serial.C wmbus_appli.c wmbus_phydatamem.c wmbus_userInterface.c
  group WMBUS_Libraries/Link
    ../../WMBUS_Libraries_STM32L/link/inc/: wmbus_crc.h wmbus_link.h wmbus_linkServices.h
  group WMBUS_Libraries/Phy
    ../../WMBUS_Libraries_STM32L/phy/inc/: wmbus_phy.h
