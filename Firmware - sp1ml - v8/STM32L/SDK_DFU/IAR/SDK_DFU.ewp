# IAR project SDK_DFU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD
  ICCARM.CCIncludePath2: ..\; ..\..\SDK_Eval_STM32L\Source\inc; ..\..\STM32L1xx_StdPeriph_Lib\Source\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc; ..\..\STM32_USB-FS-Device_Lib\Source\inc; ..\Source; ..\Source\Device_Firmware_Upgrade\inc; ..\Source\runtime
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPIRIT1_DK-DFU_Bootloader.hex
  ILINK.IlinkOutputFile: SDK_DFU.out
  ILINK.IlinkConfigDefines: CAZZO=1
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/inc
    ../../SDK_Eval_STM32L/Source/inc/: SDK_EVAL_Button.h SDK_EVAL_Config.h SDK_EVAL_Led.h
    ../Source/: stm32l1xx_conf.h stm32l1xx_it.h
  group Application/src
    ../Source/: main.c stm32l1xx_it.c
    ../../SDK_Eval_STM32L/Source/src/: SDK_EVAL_Button.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Device_Firmware_Upgrade/inc
    ../Source/Device_Firmware_Upgrade/inc/: SDK_EVAL_DFU_Desc.h SDK_EVAL_DFU_Flash_If.h SDK_EVAL_DFU_General.h SDK_EVAL_DFU_Istr.h SDK_EVAL_DFU_Mal.h SDK_EVAL_DFU_Prop.h SDK_EVAL_DFU_Pwr.h usb_conf.h
  group Device_Firmware_Upgrade/src
    ../Source/Device_Firmware_Upgrade/src/: SDK_EVAL_DFU_Desc.c SDK_EVAL_DFU_Flash_If.c SDK_EVAL_DFU_General.c SDK_EVAL_DFU_Istr.c SDK_EVAL_DFU_Mal.c SDK_EVAL_DFU_Prop.c SDK_EVAL_DFU_Pwr.c
  group Runtime
    ../Source/runtime/iar/: startup_stm32l1xx_hd.s
    ../Source/runtime/: system_stm32l1xx.c
  group STM32_USB-FS-Device_Lib/inc
    ../../STM32_USB-FS-Device_Lib/Source/inc/: usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
  group STM32_USB-FS-Device_Lib/src
    ../../STM32_USB-FS-Device_Lib/Source/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32L1xx_StdPeriph_Lib/inc
    ../../STM32L1xx_StdPeriph_Lib/Source/STM32L1xx_StdPeriph_Driver/inc/: misc.h stm32l1xx_exti.h stm32l1xx_flash.h stm32l1xx_gpio.h stm32l1xx_pwr.h stm32l1xx_rcc.h stm32l1xx_syscfg.h
  group STM32L1xx_StdPeriph_Lib/src
    ../../STM32L1xx_StdPeriph_Lib/Source/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_syscfg.c
