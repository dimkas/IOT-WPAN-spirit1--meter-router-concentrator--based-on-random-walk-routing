# IAR project SPIRIT1-WMBUS_STM8L_Example.ewp, settings and files
configuration STM8L_wmbus-meter-169 (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x250
  General.GenHeapSize: 0
  ICCSTM8.CCDefines: STM8L15X_MD; STM8L; DEVICE_TYPE_METER; DEVICE_BAND=169
  ICCSTM8.CCIncludePath2: ..\Sample_Application\inc; ..\..\SDK_Eval_STM8L\Source\inc; ..\..\..\SPIRIT1_Library_Project\Application; ..\..\..\SPIRIT1_Library_Project\SPIRIT1_Library\Source\inc; ..\..\..\SPIRIT1_Library_Project\SDK_Eval_Util\Source\inc; ..\..\..\STM8L\STM8L15x_StdPeriph_Lib\inc; ..\..\..\STM8L\WMBUS_Libraries_STM8L\appli\inc; ..\..\..\STM8L\WMBUS_Libraries_STM8L\link\inc; ..\..\..\STM8L\WMBUS_Libraries_STM8L\phy\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: SPIRIT1-WMBUS_STM8L_Example.hex
  ILINK.IlinkOutputFile: SPIRIT1-WMBUS_STM8L_Example.out
  ILINK.IlinkIcfFile: stm8l152c6_flash.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ..\..\WMBUS_Libraries_STM8L\Library\SPIRIT_WMBUS_STM8L_Library.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM8L_wmbus-meter-868 (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8L15X_MD; STM8L; DEVICE_TYPE_METER; DEVICE_BAND=868
  ILINK.IlinkExtraOptions: --no_remove
  group Sample_Application
    ../Sample_Application/src/: main.c stm8l15x_it.c
  group SDK_Eval_STM8L
    ../../SDK_Eval_STM8L/Source/src/: SDK_EVAL_Com.c SDK_EVAL_Gpio.c SDK_EVAL_Led.c SDK_EVAL_Spi_Driver.c SDK_EVAL_Timers.c
  group SPIRIT1_Library
    ../../../SPIRIT1_Library_Project/SPIRIT1_Library/Source/src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group STM8L15x_StdPeriph_Driver
    ../../STM8L15x_StdPeriph_Lib/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group WMBus_Appli
    ../../WMBUS_Libraries_STM8L/appli/src/: wmbus_appli.c
  group WMBUS_Libraries
    ../../WMBUS_Libraries_STM8L/Library/: SPIRIT_WMBUS_STM8L_Library.lib
  group WMBUS_Libraries/Link
    ../../WMBUS_Libraries_STM8L/link/inc/: wmbus_crc.h wmbus_link.h wmbus_linkServices.h
  group WMBUS_Libraries/Phy
    ../../WMBUS_Libraries_STM8L/phy/inc/: wmbus_phy.h
