# IAR project Spirit_Library_Project.ewp, settings and files
configuration SDK_BasicGeneric_A (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x200
  General.GenHeapSize: 0
  ICCSTM8.CCDefines: STM8L15X_MD; STM8L
  ICCSTM8.CCIncludePath2: .; ..\Application; ..\Application\examples; ..\..\STM8L\STM8L15x_StdPeriph_Lib\inc; ..\SDK_Eval_Util\Source\inc; ..\SPIRIT1_Library\Source\inc; ..\..\STM8L\SDK_Eval_STM8L\Source\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Spirit_Library_Project.hex
  ILINK.IlinkOutputFile: Spirit_Library_Project.out
  ILINK.IlinkIcfFile: stm8l152c6_flash.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SDK_BasicGeneric_B (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: .; ..\Application; ..\Application\examples; ..\..\STM8L\STM8L15x_StdPeriph_Lib\inc; ..\SPIRIT1_Library\Source\inc; ..\SDK_Eval_Util\Source\inc; ..\..\STM8L\SDK_Eval_STM8L\Source\inc
configuration SDK_FifoHandler_A (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: as above
configuration SDK_FifoHandler_B (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: as above
configuration SDK_Ldcr_A (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: as above
configuration SDK_Ldcr_B (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: as above
configuration SDK_StackLlp_A (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: as above
configuration SDK_StackLlp_B (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: as above
configuration SDK_WMbusStd_A (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: as above
configuration SDK_WMbusStd_B (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: as above
configuration SDK_Csma_A (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: as above
configuration SDK_Csma_B (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: as above
configuration SDK_Sniff_A (STM8, debug)
  as the first configuration, except:
configuration SDK_Sniff_B (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: as above
  group SDK_Eval
    ../../STM8L/SDK_Eval_STM8L/Source/src/: SDK_EVAL_Com.c SDK_EVAL_Gpio.c SDK_EVAL_Led.c SDK_EVAL_Spi_Driver.c SDK_EVAL_Timers.c
  group SPIRIT1_Libraries
    ../SPIRIT1_Library/Source/src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group STM8L15x_StdPeriph_Driver
    ../../STM8L/STM8L15x_StdPeriph_Lib/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group Test
    ../Application/examples/BasicGeneric/: SDK_BasicGeneric_A.c SDK_BasicGeneric_B.c
    ../Application/: SDK_Configuration_Common.h
    ../Application/examples/CsmaGeneric/: SDK_Csma_A.c SDK_Csma_B.c
    ../Application/examples/FifoHandler/: SDK_FifoHandler_A.c SDK_FifoHandler_B.c
    ../Application/examples/LdcrGeneric/: SDK_LDCR_A.c SDK_LDCR_B.c
    ../Application/examples/Sniff/: SDK_Sniff_A.c SDK_Sniff_B.c
    ../Application/examples/StackLlp/: SDK_StackLlp_A.c SDK_StackLlp_B.c
    ../Application/examples/WMbusStd/: SDK_WMbusStd_A.c SDK_WMbusStd_B.c
